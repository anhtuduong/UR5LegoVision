Commit message: define joint limits

File: moveit_ur5/config/gazebo_ur_robot.urdf (robot description, URDF)
Before this commit: robot ur_robot, 31 links, 30 joints
Links:
- removed link tavolo_link
Joints:
- removed joint tavolo_joint
